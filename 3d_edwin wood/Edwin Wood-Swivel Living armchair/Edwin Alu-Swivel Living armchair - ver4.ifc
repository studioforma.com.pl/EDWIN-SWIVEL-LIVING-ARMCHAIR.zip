Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Edwin Alu-Swivel Living armchair - ver4.ifc
Time: 2025-11-27T16:51:24
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (10)
Name
 | Edwin Alu-Swivel Living armchair_0 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_1 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_2 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_3 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_4 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_5 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_6 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_7 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_8 - ObjectType: SketchupGroup
 | Edwin Alu-Swivel Living armchair_9 - ObjectType: SketchupGroup
